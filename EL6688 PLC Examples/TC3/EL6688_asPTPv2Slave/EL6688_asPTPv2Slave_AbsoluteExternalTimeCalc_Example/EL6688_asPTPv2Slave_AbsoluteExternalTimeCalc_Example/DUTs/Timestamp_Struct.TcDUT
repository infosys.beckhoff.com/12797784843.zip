TYPE Timestamp_Struct :
STRUCT
	sCurExtTaskTime64:STRING(80);
	sCurExtTaskUtcTime64:STRING(80);
	sCurExtTime64:STRING(80);
	sCurExtUtcTime64:STRING(80);
END_STRUCT
END_TYPE
