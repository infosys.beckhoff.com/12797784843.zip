{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_PTP_VERSION :
(
	UNDEFINED := 0,
	PTPv1:=16,
	PTPv2:=32
);
END_TYPE
